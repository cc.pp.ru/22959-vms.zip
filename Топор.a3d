# KOMPAS-3D assembly (Топор.a3d)

Referenced files in C:\Documents and Settings\User\Рабочий стол\: Обух.m3d, Ручка .m3d, Клин.m3d